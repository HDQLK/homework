# Keil uVision project TEST.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TEST +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source Group 1
    ./: TEST.s
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
